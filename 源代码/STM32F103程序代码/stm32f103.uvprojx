# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\device\inc;.\hardware\DHT11
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: stm32f10x_rcc.c misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c
  group hardware
    ./hardware/src/: delay.c usart.c sys.c HMI_Rx.c Timer.c AD.c dht11.c Get_Huangjing.c max30102.c read30102.c
  group user
    ./user/: main.c
  group net_device
    ./NET/device/src/: esp8266.c
software components: CMSIS:CORE 5.0.1
